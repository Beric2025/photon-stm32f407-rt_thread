# Keil uVision project Photon.uvprojx, settings and files
target Photon (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: photon_stm32f407 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.dis" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32F407xx,__RT_KERNEL_SOURCE__,RT_USING_USER_MAIN,RT_USING_FINSH
  c include: ..\third_party\STM32F4xx_HAL_Driver\Inc;..\third_party\STM32F4xx_HAL_Driver\Inc\Legacy;..\third_party\CMSIS\Device\ST\STM32F4xx\Include;../third_party/CMSIS/Include;..\third_party\rt-thread\include;..\third_party\rt-thread\libcpu\arm\cortex-m4;..\third_party\rt-thread\components\finsh;..\port\rtthread;..\third_party\lwIP\src\include;..\port\stm32f407\lwip;..\third_party\lwIP;..\interface\gpio;..\interface\uart;..\interface\can;..\interface\flash;..\interface\iic;..\interface\spi;..\interface\ethernet;..\interface\tim;..\interface\adc;..\drivers\delay;..\drivers;..\port\stm32f407\bsp;..\port\stm32f407\system;..\app\app_core\Inc;..\app\share\Inc;..\Drivers\pcf8574;..\Drivers\battery;..\Drivers\iap;..\Drivers\light;..\Drivers\motor;..\Drivers\net;..\Drivers\ultrasonic;..\Drivers\eth_phy;..\port\lwip\arch;..\port\lwip\common;..\port\lwip;..\interface\dac;..\interface\i2s;..\interface\lp;..\interface\rng;..\interface\rtc;..\interface\wdg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../port/stm32f407/startup/: startup_stm32f407xx.s
  group ThirdParty/STM32F4xx_HAL_Driver
    ../third_party/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group ThirdParty/RT-Thread/kernel
    ../third_party/rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c scheduler_comm.c thread.c timer.c
    ../third_party/rt-thread/src/klibc/: kstring.c kstdio.c rt_vsnprintf_tiny.c rt_vsscanf.c kerrno.c
  group ThirdParty/RT-Thread/port
    ../third_party/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group ThirdParty/RT-Thread/finsh
    ../third_party/rt-thread/components/finsh/: shell.c cmd.c msh.c msh_parse.c msh_file.c
  group ThirdParty/LWIP/src/api
    ../third_party/lwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group ThirdParty/LWIP/src/core
    ../third_party/lwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../third_party/lwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group ThirdParty/LWIP/src/netif
    ../third_party/lwIP/src/netif/: ethernet.c bridgeif.c bridgeif_fdb.c
  group Port/RT-Thread
    ../port/rtthread/: board.c finsh_port.c
  group Port/lwIP
    ../port/lwip/common/: lwip_port.c
    ../port/lwip/arch/: ethernetif.c sys_arch.c
  group Port/stm32f407
    ../port/stm32f407/system/: gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_stm32f4xx.c
    ../port/stm32f407/bsp/: bsp_eth.c bsp_gpio.c bsp_uart.c bsp_adc.c bsp_can.c bsp_cap.c bsp_dac.c bsp_flash.c bsp_i2c.c bsp_i2s.c bsp_pwm.c bsp_rng.c bsp_rtc.c bsp_spi.c bsp_wdg.c
  group Interface
    ../interface/adc/: adc_dev.c
    ../interface/can/: can_dev.c
    ../interface/ethernet/: eth_dev.c
    ../interface/flash/: flash_dev.c
    ../interface/gpio/: gpio_dev.c
    ../interface/iic/: i2c_dev.c my_i2c.c
    ../interface/spi/: spi_dev.c
    ../interface/tim/: cap_dev.c pwm_dev.c
    ../interface/uart/: uart_dev.c
    ../interface/dac/: dac_dev.c
    ../interface/i2s/: i2s_dev.c
    ../interface/lp/: lp_dev.c
    ../interface/rng/: rng_dev.c
    ../interface/rtc/: rtc_dev.c
    ../interface/wdg/: wdg_dev.c
  group Drivers
    ../drivers/eth_phy/: eth_phy.c
    ../drivers/pcf8574/: pcf8574.c
    ../drivers/net/: net1_dev.c net_dev.c
    ../drivers/battery/: battery_dev.c xingneng_dev.c adc_sample_dev.c
    ../drivers/iap/: iap.c
    ../drivers/light/: tm512ac_dev.c light_dev.c
    ../drivers/motor/: hub_motor_dev.c motor_dev.c
    ../drivers/ultrasonic/: dypa21_dev.c ultrasonic_dev.c
    ../Drivers/net/: tcp_echo.c
    ../drivers/delay/: delay_dev.c
  group Application
    ../app/share/Src/: log_print.c match_mode.c
    ../app/app_core/Src/: app_manage.c app_version.c app_battery.c app_light.c app_motor.c app_ultrasonic.c app_adc_battery.c app_led.c app_network.c
